<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\01-Polling-Problem\01-Polling-Problem.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\02-Systick-Interrupt\02-Systick-Interrupt.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\03-GPIO-Systick-Interrupt\03-GPIO-Systick-Interrupt.ewp</path>
    </project>
    <batchBuild />
</workspace>
